Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 1fa74aff-9e89-4425-b581-2d3ccbfd1548, NumberOfSaves: 1]
File name: 0001
Time: 2025-12-15T16:41:21+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12519370_EU1_KU7175D:36717510_EU1_12519370_KU7175D, (2)
In: Default
Type - Material: z_Miele_Design_CLST, z_Miele_Design_Glass Black, z_Miele_Design_OBSW, z_Miele_Design_Cast, <Unnamed>, z_Miele_Connection_Connection_Modul
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 597 mm; Height: 859 mm; Depth: 556 mm
Pset_BuildingElementProxyCommon - Reference: 36717510_EU1_12519370_KU7175D; sets with these values: 2
